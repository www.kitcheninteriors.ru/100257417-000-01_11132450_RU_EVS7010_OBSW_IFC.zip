Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-06-17T11:59:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 17 11:59:10 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{8C9887FE-65DA-4E9C-990F-F8A532EDC3E7}\ifc * Database version: 5507 * Database creation date: Thu Jun 17 11:59:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 17 11:59:09 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 17 11:59:09 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 30701021_RU_11132450_EVS7010_OBSW, 11132450_RU_EVS7010_OBSW:30701021_RU_11132450_EVS7010_OBSW:204016
In: Level 1
Type - Classification: EVS7000 (Uniformat); Material: z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 30701021_RU_11132450_EVS7010_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
